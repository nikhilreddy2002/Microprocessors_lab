# Keil uVision project lab_1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: lab_1
  c flags: Optim=1
  group Source Group 1
    ./: Excercise1_2.s Excercise1_1.s Excercise1_3.s
